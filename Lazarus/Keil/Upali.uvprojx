# Keil uVision project Upali.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Upali
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, __FPU_PRESENT = 1 PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: ../Include; C:\Keil_v5\ARM\CMSIS\Include; C:\ti\TivaWare_C_Series-2.1.4.178; ../
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Files
    ./: main.c
    ../: settings.h sampler.c sampler.h melfilterconfig.h melfilterconfig.c mfcc.c mfcc.h test_frame.c parameters.h parameters.c forward.h forward.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, Device:Startup 1.0.1
